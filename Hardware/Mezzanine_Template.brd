File: Hardware/Mezzanine_Template.brd (EAGLE design)
At the start: 30.5 x 44.5 mm, 6 parts

Commit message: Fixed $ in names, move name from silk to tNames
Parts:
- renumbered U$2 to U2, U$3 to U3
